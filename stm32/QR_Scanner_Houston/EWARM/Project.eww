<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\TCP_ServerW5500.ewp</path>
  </project>
  <batchBuild />
</workspace>
